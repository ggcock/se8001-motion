# Keil uVision project SE8001-DEMO.uvprojx, settings and files
target SE8001_01 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SE8001_DEMO +hex
  c flags: Optim=2 oTime=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,xUSE_IAP
  c misc: --c99
  c include: ..\LIB\STM32F10x_FWLib\inc;..\Lib\Core;..\uCosII\CONFIG;..\uCosII\CORE;..\uCosII\PORT;..\Driver\Chip;..\Driver\Common;..\Driver\Hal;..\Driver\Mcu;..\Driver\Other;..\App;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group App
    ../App/: app.c com_server.c
  group User
    ../User/: main.c queue.c stm32f10x_it.c system_stm32f10x.c ins_common.c ins_exe.c
  group Driver::Chip
    ../Driver/Chip/: IrSensor.c
    ../Driver/Chip/L3G4200D/: L3G4200D.c
    ../Driver/Chip/ADXL345/: ADXL345.c
  group Driver::Mcu
    ../Driver/Mcu/: exti.c flash.c timer.c i2c.c
  group Driver::Hal
    ../Driver/Hal/: halCom.c halPwm.c halIMU.c
  group Driver::Common
    ../Driver/Common/: delay.c system.c usart.c
  group Driver::Other
    ../Driver/Other/: arithmetic.c crc8.c crc16.c my_string.c
  group uCosII
    ../uCosII/CONFIG/: os_cfg.h includes.h
    ../uCosII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../uCosII/PORT/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group Lib:Core
    ../Lib/Core/: core_cm3.c startup_stm32f10x_hd.s
  group Lib::STM32F10x_FWLib
    ../Lib/STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Doc
    ../Doc/: Notes.txt
